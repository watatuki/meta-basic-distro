
IMAGE_INSTALL:append = "\
    kernel-modules \
    \
    qtbase \
    qtdeclarative \
    qtquickcontrols2 \
    qttools \
    qttranslations-qtbase \
    qttranslations-qtdeclarative \
    qttranslations-qtquickcontrols2 \
    qt3d \
    qtquick3d \
    qtwayland \
    \
    qtwayland-examples qtquick3d-examples \
    "

IMAGE_LINGUAS = "ja-jp en-us"
