PACKAGECONFIG = "\
    wayland-client \
    wayland-server \
    examples \
"

PACKAGECONFIG:class-native = ""
PACKAGECONFIG:class-nativesdk = ""

